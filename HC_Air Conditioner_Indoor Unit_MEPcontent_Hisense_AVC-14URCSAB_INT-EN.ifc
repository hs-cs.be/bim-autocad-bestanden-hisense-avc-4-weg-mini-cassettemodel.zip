Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-02-02T13:22:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.428.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Feb 02 13:22:07 2018 * Host: B3ROBRAWR3858 * Database: C:\Users\DD\AppData\Local\Temp\{09D1435B-4DF8-4DBD-B0F3-236F2F128A52}\ifc * Database version: 5507 * Database creation date: Fri Feb 02 13:22:07 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Fri Feb 02 13:22:07 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Feb 02 13:22:07 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcUnitaryEquipment: AVC-14URCSAB, HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN:AVC-14URCSAB:1305716
In: V00
Type - PredefinedType: AIRCONDITIONINGUNIT; Material: Color RGB 110-110-110, Color RGB 245-245-245, Color RGB 075-079-084, Color RGB 187-080-046, Color RGB 121-089-089, Color RGB 072-102-244
Type - Dimensions - Depth: 650 mm; Drain Diameter: 32 mm; Height: 300 mm; Refrigerant Gas Diameter: 15.9 mm; Refrigerant Liquid Diameter: 6.35 mm; Width: 650 mm
Type - Electrical - Hertz: 50 Hz; Motor Power: 71 W; Phase: 1; Voltage: 230 V
Type - Identity Data - Article Description: 4-Way Cassette; Article Type: AVC-14URCSAB; Content Supplier URL: www.mepcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: 4-Way Cassette; EMCS Version: 3.0; ETIM Article Class: EC000403; Family Version: 11.12; Manufacturer: Hisense; Manufacturer Art. No.: AVC-14URCSAB; Manufacturer URL: http://www.hs-cs.nl/; MEPcontent Class: AIR_CONDITIONER_INDOOR_UNIT; Model: AVC-14URCSAB; OmniClass Number: 23.75.10.24.21.27; OmniClass Title: Unitary Air Conditioning Equipment; Product Line: Mini 4-Way cassette series; Revit Version: 2016; Type Name: AVC-14URCSAB; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Blue: Color RGB 072-102-244; Brown: Color RGB 121-089-089; Dark Grey: Color RGB 110-110-110; Grey: Color RGB 180-180-180; Light Grey: Color RGB 220-220-220; Logo: Color RGB 075-079-084; Medium White: Color RGB 220-220-220; White: Color RGB 245-245-245; Yellow: Color RGB 187-080-046
Type - Mechanical - Loads - Airflow Rate (m3/min): 10.9; Cooling Capacity (kW): 4.3; External Static Pressure (Pa): 0; Heating Capacity (kW): 4.9; Sound Pressure Level (dB(A)): 33; Unit Weight (kg): 22.4
Type - Other - Category: Mechanical Equipment; Family Name: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN; Refrigerant Type: R410A; Void Length: 600 mm; Void Width: 600 mm
Pset_ManufacturerTypeInformation - Manufacturer: Hisense
Constraints - Offset: 0 mm
Dimensions - Area: 5.15537 m2; Ceiling Offset: 0 mm; Volume: 1.50904 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Refrigerant Gas Flow: 0 m3/s; Refrigerant Liquid Flow: 0 m3/s; System Classification: Sanitary,Undefined,Power,Undefined
Other - Back Clearance Safe: 100 mm; Bottom Clearance Safe: 1000 mm; Family: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN: AVC-14URCSAB; Family and Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN: AVC-14URCSAB; Front Clearance Safe: 100 mm; Left Clearance Safe: 500 mm; Offset from Ceiling: 0 mm; Offset Start: -105 mm; Right Clearance Safe: 500 mm; Type: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN: AVC-14URCSAB; Type Id: HC_Air Conditioner_Indoor Unit_MEPcontent_Hisense_AVC-05-17_INT-EN: AVC-14URCSAB
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Clearance: 100 mm; Bottom Clearance: 1000 mm; Front Clearance: 100 mm; Left Clearance: 500 mm; Right Clearance: 500 mm; Service Space: no
